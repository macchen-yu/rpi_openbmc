DEPENDS:append:ast2700-a0 = " static-inventory"
