# Sync to the latest x86-power-control. We can remove it after rebasing OpenBMC.
SRCREV = "b1e34a11f5c64a7c4225fb4cf15ee7f9368cbef4"
